# IAR project NewLCBSimulator.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105VC ST STM32F105VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: Inc\; Libraries\CMSIS\CM3\CoreSupport\; Libraries\STM32F10x_StdPeriph_Driver\inc\; BootAPI\inc\; Libraries\FileSystem\fat\src\common\; Libraries\FileSystem\fat\src\mst\; Libraries\FileSystem\os\; Libraries\FileSystem\os\nrtos\; Libraries\FileSystem\; Libraries\FileSystem\usb_host\; Libraries\FileSystem\usb_host\usb_driver\mst\; Libraries\FileSystem\usb_host\usb_driver\; Libraries\FileSystem\usb_host\pmgr\; Libraries\FileSystem\usb_host\stm32uh\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WMS20260126_IAR9.bin
  ILINK.IlinkOutputFile: NewLCBSimulator.out
  ILINK.IlinkIcfFile: Link\JHT_stm32f105V1.2_IAR9.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkIcfFile: D:\JohnsonProject\TestTeam\Test Tool\New Mini Black Box\SW\STM32F105 LCB Simulator\Link\JHT_stm32f105V1.2.icf
  group Boot/API
    BootAPI/src/: Boot.c Boot_it.c Boot_startup_stm32f10x_cl.s Bootflash.c Stm32GPIO.c
  group Boot/CMSIS
    Source/: system_stm32f10x.c
  group Boot/DISPLAY
    BootAPI/src/: BootLCM.c
  group Boot/USB/FAT
    Libraries/FileSystem/fat/src/common/: common.c fat.c fat_lfn.c fat_m.c port_f.c
  group Boot/USB/FAT/MST
    Libraries/FileSystem/fat/src/mst/: mst.c
  group Boot/USB/HOST
    Libraries/FileSystem/usb_host/: usb_host.c usb_utils.c
  group Boot/USB/HOST/DEVICE/MST
    Libraries/FileSystem/usb_host/usb_driver/mst/: scsi.c usb_mst.c
  group Boot/USB/HOST/PMGR
    Libraries/FileSystem/usb_host/pmgr/: pmgr.c
  group Boot/USB/HOST/STM32uh
    Libraries/FileSystem/usb_host/stm32uh/: stm32uh.c stm32uh_hub.c stm32uh_hw.c
  group Boot/USB/OS
    Libraries/FileSystem/os/nrtos/: os_nrtos.c
  group Libraries
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group LinkFile
    Link/: JHT_stm32f105V1.2_IAR9.icf
  group UserProgram
    Source/: ADC.c ADS1100.c EE93CXX.C Encoder.c JHTLCBComm.c LCBSimulator.c LCM.c LCMDisplay.c Operation.c RowerWatts.c Screen.c SimulatorMain.c Sintable.c stm32f10x_it.c
  group UserProgram/LowLevelInitial
    BootAPI/LowLevelInitial/: lcb_startup_stm32f10x_cl.s manual_init.c
